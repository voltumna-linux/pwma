require recipes-core/images/voltumna-sde.inc
require include/canoned.inc

IMAGE_INSTALL_append += "nghttp2-dev"
